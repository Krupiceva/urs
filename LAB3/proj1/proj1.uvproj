# Keil uVision project proj1.uvproj, settings and files
target Target 1 (MCS-51)
  device: 80C31 NXP
  cpu: IRAM(0-0x7F) CLOCK(33000000)
  output: proj1 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: zad1.a51
